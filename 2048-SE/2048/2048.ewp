# IAR project 2048.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: OLDFUNCTIONS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS; SE
  group (top)
    ../../src/: 2048.c
    ../C++/: _cpp2.cpp
    ./: conf_loader.cpp config_data.c main.c rand.c
    ../include/: func.asm
